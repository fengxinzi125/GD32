# Keil uVision project GD32KeilPrj.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: GD32F303ZE GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.1
  cpu: IRAM(0x20000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: GD32KeilPrj +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F30X_HD
  c include: ..\FW\Include;..\App\Main;..\App\LED;..\ARM\SysTick;..\ARM\System;..\App\DataType;..\ARM\NVIC;..\HW\RCU;..\HW\Timer;..\HW\UART0;..\App\LCD;..\App\Picture;..\App\IICCommon;..\App\Touch;..\HW\EXMC;..\App\EmbGUI\App;..\App\EmbGUI\Module;..\App\EmbGUI\Platform;..\App\EmbGUI\Widget;..\App\SDCard;..\App\KeyOne;..\TPSW\FatFs\src;..\App\FatFsTest;..\App\Malloc;..\HW\SPI;..\App\GD25QXX;..\App\FontLib
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group App
    ../App/Main/: Main.c
    ../App/LED/: LED.c
    ../App/LCD/: LCD.c
    ../App/Picture/: tjpgd.c JPEG.c BMP.c
    ../App/IICCommon/: IICCommon.c
    ../App/Touch/: GT1151Q.c Touch.c
    ../App/EmbGUI/Widget/: ButtonWidget.c LineEditWidget.c SliderWidget.c TextWidget.c
    ../App/EmbGUI/Platform/: GUIPlatform.c
    ../App/EmbGUI/Module/: GUIButton.c
    ../App/EmbGUI/App/: GUITop.c
    ../App/SDCard/: SDCard.c
    ../App/KeyOne/: KeyOne.c ProcKeyOne.c
    ../App/FatFSTest/: ReadBookByte.c
    ../App/FatFsTest/: FatFsTest.c
    ../App/Malloc/: Malloc.c
    ../App/GD25QXX/: GD25QXX.c
    ../App/FontLib/: FontLib.c
  group HW
    ../HW/RCU/: RCU.c
    ../HW/Timer/: Timer.c
    ../HW/UART0/: Queue.c UART0.c
    ../HW/EXMC/: EXMC.c
    ../HW/SPI/: SPI.c
  group TPSW
    ../TPSW/FatFS/src/: diskio.c ff.c
    ../TPSW/FatFS/src/option/: cc936.c
  group FW
    ../FW/Source/: gd32f30x_fmc.c gd32f30x_gpio.c gd32f30x_misc.c gd32f30x_rcu.c gd32f30x_timer.c gd32f30x_usart.c gd32f30x_exmc.c gd32f30x_dma.c gd32f30x_sdio.c gd32f30x_adc.c gd32f30x_dac.c gd32f30x_spi.c
  group ARM
    ../ARM/System/: gd32f30x_it.c system_gd32f30x.c startup_gd32f30x_hd.s
    ../ARM/NVIC/: NVIC.c
    ../ARM/SysTick/: SysTick.c
software components: CMSIS:CORE 5.4.0
