/*********************************************************************************************************
* 模块名称：SPI.c
* 摘    要：SPI模块
* 当前版本：1.0.0
* 作    者：Leyutek(COPYRIGHT 2018 - 2021 Leyutek. All rights reserved.)
* 完成日期：2021年07月01日
* 内    容：
* 注    意：注意勾选Options for Target 'Target1'->Code Generation->Use MicroLIB，否则printf无法使用                                                                  
**********************************************************************************************************
* 取代版本：
* 作    者：
* 完成日期：
* 修改内容：
* 修改文件：
*********************************************************************************************************/

/*********************************************************************************************************
*                                              包含头文件
*********************************************************************************************************/
#include "SPI.h"
#include "SysTick.h"

/*********************************************************************************************************
*                                              宏定义
*********************************************************************************************************/

/*********************************************************************************************************
*                                              内部变量
*********************************************************************************************************/

/*********************************************************************************************************
*                                              枚举结构体定义
*********************************************************************************************************/

/*********************************************************************************************************
*                                              内部函数声明
*********************************************************************************************************/

/*********************************************************************************************************
*                                              内部函数实现
*********************************************************************************************************/
/*********************************************************************************************************
*                                              API函数实现
*********************************************************************************************************/
/*********************************************************************************************************
* 函数名称：InitSPI0
* 函数功能：初始化SPI0
* 输入参数：void
* 输出参数：void
* 返 回 值：void
* 创建日期：2021年07月01日
* 注    意：
*********************************************************************************************************/
void InitSPI0(void)
{
  //SPI初始化结构体
  spi_parameter_struct spi_init_struct;

  rcu_periph_clock_enable(RCU_GPIOA); //使能GPIOA的时钟
  rcu_periph_clock_enable(RCU_AF);    //使能AF的时钟
  rcu_periph_clock_enable(RCU_SPI0);  //使能SPI0的时钟

  //禁止SPI0设备
  spi_disable(SPI0);

  //SPI0_CLK(PA5), SPI0_MISO_IO1(PA6), SPI0_MOSI_IO0(PA7)
  gpio_init(GPIOA, GPIO_MODE_AF_PP, GPIO_OSPEED_50MHZ, GPIO_PIN_5 | GPIO_PIN_6 | GPIO_PIN_7);

  //配置SPI0
  spi_init_struct.device_mode          = SPI_MASTER;               //SPI主机
  spi_init_struct.trans_mode           = SPI_TRANSMODE_FULLDUPLEX; //全双工模式
  spi_init_struct.frame_size           = SPI_FRAMESIZE_8BIT;       //8位数据帧
  spi_init_struct.nss                  = SPI_NSS_SOFT;             //软件管理NSS（片选）
  spi_init_struct.endian               = SPI_ENDIAN_MSB;           //高位在前，低位在后数据位顺序
  spi_init_struct.clock_polarity_phase = SPI_CK_PL_HIGH_PH_2EDGE;  //时钟信号上升沿有效且第二个时钟跳变沿为有效采样边沿
  spi_init_struct.prescale             = SPI_PSC_256;              //时钟分频系数（由SYSCLK分频）
  spi_init(SPI0, &spi_init_struct);                                //根据参数配置SPI0

  //配置硬件CRC计算
  spi_crc_polynomial_set(SPI0, 7); 

  //使能SPI0设备
  spi_enable(SPI0);
}

/*********************************************************************************************************
* 函数名称：SPI0SetSpeed
* 函数功能：设置SPI0传输速度
* 输入参数：void 
* 输出参数：void
* 返 回 值：void
* 创建日期：2021年07月01日
* 注    意：
*********************************************************************************************************/
void SPI0SetSpeed(u32 pre)
{
  spi_disable(SPI0);
  SPI_CTL0(SPI0) &= 0XFFC7;
  SPI_CTL0(SPI0)|= pre;
  spi_enable(SPI0);
}

/*********************************************************************************************************
* 函数名称：SPI0ReadWriteByte
* 函数功能：SPI0读写单字节
* 输入参数：void 
* 输出参数：void
* 返 回 值：void
* 创建日期：2021年07月01日
* 注    意：
*********************************************************************************************************/
unsigned char SPI0ReadWriteByte(unsigned char byte)
{
  //等待发送缓冲区空闲（等待上一批数据发送完成）
  while(RESET == spi_i2s_flag_get(SPI0, SPI_FLAG_TBE));

  //发送数据
  spi_i2s_data_transmit(SPI0, byte);

  //等待接收缓冲区非空（接收数据）
  while(RESET == spi_i2s_flag_get(SPI0, SPI_FLAG_RBNE));

  //获取SPI0数据输入
  return(spi_i2s_data_receive(SPI0));
}

/*********************************************************************************************************
* 函数名称：InitSPI1
* 函数功能：初始化SPI1
* 输入参数：void
* 输出参数：void
* 返 回 值：void
* 创建日期：2021年07月01日
* 注    意：
*********************************************************************************************************/
void InitSPI1(void)
{
  //SPI初始化结构体
  spi_parameter_struct spi_init_struct;

  rcu_periph_clock_enable(RCU_GPIOB); //使能GPIOB的时钟
  rcu_periph_clock_enable(RCU_AF);    //使能AF的时钟
  rcu_periph_clock_enable(RCU_SPI1);  //使能SPI1的时钟

  //禁止SPI1设备
  spi_disable(SPI1);

  //SPI1_CLK(PB13), SPI1_MISO_IO1(PB14), SPI1_MOSI_IO0(PB15)
  gpio_init(GPIOB, GPIO_MODE_AF_PP, GPIO_OSPEED_50MHZ, GPIO_PIN_13 | GPIO_PIN_14 | GPIO_PIN_15);

  //配置SPI1
  spi_init_struct.device_mode          = SPI_MASTER;               //SPI主机
  spi_init_struct.trans_mode           = SPI_TRANSMODE_FULLDUPLEX; //全双工模式
  spi_init_struct.frame_size           = SPI_FRAMESIZE_8BIT;       //8位数据帧
  spi_init_struct.nss                  = SPI_NSS_SOFT;             //软件管理NSS（片选）
  spi_init_struct.endian               = SPI_ENDIAN_MSB;           //高位在前，低位在后数据位顺序
  spi_init_struct.clock_polarity_phase = SPI_CK_PL_HIGH_PH_2EDGE;  //时钟信号上升沿有效且第二个时钟跳变沿为有效采样边沿
  spi_init_struct.prescale             = SPI_PSC_2;                //时钟分频系数（由SYSCLK分频）
  spi_init(SPI1, &spi_init_struct);                                //根据参数配置SPI1

  //配置硬件CRC计算
  spi_crc_polynomial_set(SPI1, 7); 

  //使能SPI1设备
  spi_enable(SPI1);
}

/*********************************************************************************************************
* 函数名称：SPI1SetSpeed
* 函数功能：设置SPI1传输速度
* 输入参数：void 
* 输出参数：void
* 返 回 值：void
* 创建日期：2021年07月01日
* 注    意：
*********************************************************************************************************/
void SPI1SetSpeed(u32 pre)
{
  spi_disable(SPI1);
  SPI_CTL0(SPI1) &= 0XFFC7;
  SPI_CTL0(SPI1)|= pre;
  spi_enable(SPI1);
}

/*********************************************************************************************************
* 函数名称：SPI1ReadWriteByte
* 函数功能：SPI1读写单字节
* 输入参数：void 
* 输出参数：void
* 返 回 值：void
* 创建日期：2021年07月01日
* 注    意：
*********************************************************************************************************/
unsigned char SPI1ReadWriteByte(unsigned char byte)
{
  //等待发送缓冲区空闲（等待上一批数据发送完成）
  while(RESET == spi_i2s_flag_get(SPI1, SPI_FLAG_TBE));

  //发送数据
  spi_i2s_data_transmit(SPI1, byte);

  //等待接收缓冲区非空（接收数据）
  while(RESET == spi_i2s_flag_get(SPI1, SPI_FLAG_RBNE));

  //获取SPI1数据输入
  return(spi_i2s_data_receive(SPI1));
}
