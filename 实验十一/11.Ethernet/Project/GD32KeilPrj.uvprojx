# Keil uVision project GD32KeilPrj.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: GD32F303ZE GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.1
  cpu: IRAM(0x20000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: GD32KeilPrj +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F30X_HD
  c include: ..\FW\Include;..\App\Main;..\App\LED;..\ARM\SysTick;..\ARM\System;..\App\DataType;..\ARM\NVIC;..\HW\RCU;..\HW\Timer;..\HW\UART0;..\App\LCD;..\App\Picture;..\App\IICCommon;..\App\Touch;..\HW\EXMC;..\App\EmbGUI\App;..\App\EmbGUI\Module;..\App\EmbGUI\Platform;..\App\EmbGUI\Widget;..\App\Malloc;..\App\Enternet;..\TPSW\LWIP;..\TPSW\LWIP\arch;..\TPSW\LWIP\lwip-1.4.1\src\include;..\TPSW\LWIP\lwip-1.4.1\src\include\ipv4;..\TPSW\LWIP\lwip-1.4.1\src\include\netif;..\TPSW\LWIP\lwip_app\LWIPComm;..\TPSW\LWIP\lwip_app\TCPServerBase
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group App
    ../App/Main/: Main.c
    ../App/LED/: LED.c
    ../App/LCD/: LCD.c
    ../App/Picture/: tjpgd.c JPEG.c BMP.c
    ../App/IICCommon/: IICCommon.c
    ../App/Touch/: GT1151Q.c Touch.c
    ../App/EmbGUI/Widget/: ButtonWidget.c LineEditWidget.c SliderWidget.c TextWidget.c
    ../App/EmbGUI/Platform/: GUIPlatform.c
    ../App/EmbGUI/Module/: GUIButton.c GUILineEdit.c GUITerminal.c
    ../App/EmbGUI/App/: GUITop.c
    ../App/Malloc/: Malloc.c
    ../App/Enternet/: DM9000.c EnternetTop.c
  group HW
    ../HW/RCU/: RCU.c
    ../HW/Timer/: Timer.c
    ../HW/UART0/: Queue.c UART0.c
    ../HW/EXMC/: EXMC.c
  group FW
    ../FW/Source/: gd32f30x_fmc.c gd32f30x_gpio.c gd32f30x_misc.c gd32f30x_rcu.c gd32f30x_timer.c gd32f30x_usart.c gd32f30x_exmc.c gd32f30x_dma.c gd32f30x_sdio.c gd32f30x_adc.c gd32f30x_dac.c gd32f30x_exti.c
  group ARM
    ../ARM/System/: gd32f30x_it.c system_gd32f30x.c startup_gd32f30x_hd.s
    ../ARM/NVIC/: NVIC.c
    ../ARM/SysTick/: SysTick.c
  group LWIP_APP
    ../TPSW/LWIP/lwip_app/LWIPComm/: LWIPComm.c
    ../TPSW/LWIP/lwip_app/TCPServerBase/: TCPServerBase.c
  group LWIP_CORE
    ../TPSW/LWIP/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../TPSW/LWIP/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c lwip_sys.c mem.c memp.c netif.c pbuf.c raw.c stats.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
  group LWIP_ARCH
    ../TPSW/LWIP/arch/: sys_arch.c
  group LWIP_API
    ../TPSW/LWIP/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group LWIP_NETIF
    ../TPSW/LWIP/lwip-1.4.1/src/netif/: etharp.c ethernetif.c
software components: CMSIS:CORE 5.4.0
